# Repository Andreas-Ley/appcvrobot_electronics

## KiCad design mainboard/main.kicad_pcb

Parts:
C_CurrOpAmp1: 1uF; CP_Radial_D5.0mm_P2.50mm
C_MD_L1: 100uF; CP_Radial_D5.0mm_P2.50mm
C_MD_R1: 100uF; CP_Radial_D5.0mm_P2.50mm
C_P_Sw_Hold1: 100uF; CP_Radial_D5.0mm_P2.50mm
Con_AddOn1: Conn_01x09; JST_XH_B9B-XH-A_1x09_P2.50mm_Vertical
Con_Battery1: Conn_01x06; JST_XH_B6B-XH-A_1x06_P2.50mm_Vertical
Con_Display1: Conn_01x04; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
Con_Motor_L1: Conn_01x04; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
Con_Motor_R1: Conn_01x04; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
Con_P_Sw1: Conn_01x02; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
Con_RPi1: Conn_01x08; JST_XH_B8B-XH-A_1x08_P2.50mm_Vertical
Con_Stepdown1: Conn_01x03; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
Con_Switch1: Conn_01x03; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
CurrentDrawOpAmp1: LM358; DIP-8_W7.62mm_Socket
CurrentSensor1: ACS712Breakout; ACS712BreakoutBoardUpSideDown
Diode_P_In1: 1N 4448; D_T-1_P5.08mm_Horizontal
LevelShifter_Display1: LevelShifter; LevelShifterBreakoutBoard
MD_L1: Pololu_Breakout_A4988; Pololu_Breakout-16_15.2x20.3mm
MD_R1: Pololu_Breakout_A4988; Pololu_Breakout-16_15.2x20.3mm
MicroController1: IZOKEEProMini; Arduino_Pro_Mini_Socket_IZOKEE_no_programming_no_ext_wire
POT_Batt_12, POT_Batt_23: 200k; Potentiometer_Bourns_3296W_Vertical
POT_Batt_P1: 200k; Potentiometer_Bourns_3296W_Vertical
POT_P_Sw_Sense1: 100K; Potentiometer_Bourns_3296W_Vertical
POT_PowerGate1: 100K; Potentiometer_Bourns_3296W_Vertical
Q1: 2N3904; TO-92_Inline_Wide
Q2, Q4, Q5: ZVP2106A; TO-92L_Inline_Wide
Q3: STP10P6F6; TO-220-3_Vertical
R_BaseLim1: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R_C_Lim1: 220; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R_I_1: 10K; R_Axial_DIN0207_L6.3mm_D2.5mm_P5.08mm_Vertical
R_I_2, R_I_3: 33K; R_Axial_DIN0207_L6.3mm_D2.5mm_P5.08mm_Vertical
R_I_4: 22K; R_Axial_DIN0207_L6.3mm_D2.5mm_P5.08mm_Vertical

Connections:
+3V3: Con_AddOn1.5, Con_RPi1.4, LevelShifter_Display1.3 (LV), MD_L1.2 (VDD), MD_R1.2 (VDD), MicroController1.25 (VCC)
+5V: C_CurrOpAmp1.1, Con_AddOn1.4, Con_Display1.3, Con_RPi1.5, Con_Stepdown1.2, CurrentDrawOpAmp1.8 (V+), CurrentSensor1.1 (VCC), LevelShifter_Display1.10 (HV), R_I_2.1
+12V: C_MD_L1.1, C_MD_R1.1, Con_AddOn1.8, Con_AddOn1.9, Con_Stepdown1.1, MD_L1.8 (VMOT), MD_R1.8 (VMOT), Q3.2 (D)
+BATT: Con_Battery1.3, Con_Battery1.4, Con_P_Sw1.1, POT_PowerGate1.1, Q2.1 (S), Q3.3 (S)
-BATT: Con_Battery1.5, Con_Battery1.6, CurrentSensor1.4 (I1)
ADC_Batt_12: MicroController1.21 (A2/D16), POT_Batt_12.2
ADC_Batt_23: MicroController1.23 (A3/D17), POT_Batt_23.2
ADC_Batt_Curr: CurrentDrawOpAmp1.1, MicroController1.19 (A0/D14), R_I_3.2
ADC_Batt_P: MicroController1.20 (A1/D15), POT_Batt_P1.2
BATT_Cell_1_2: Con_Battery1.2, Q5.1 (S)
BATT_Cell_2_3: Con_Battery1.1, Q4.1 (S)
Dir_L: MD_L1.16 (DIR), MicroController1.10 (D7/IN1)
Dir_R: MD_R1.16 (DIR), MicroController1.1 (D1/TXD)
Enable_Steppers: MD_L1.9 (~ENABLE), MD_R1.9 (~ENABLE), MicroController1.11 (D8/CLKO/ICP1)
GND: C_CurrOpAmp1.2, C_MD_L1.2, C_MD_R1.2, C_P_Sw_Hold1.2, Con_AddOn1.6, Con_AddOn1.7, Con_Display1.4, Con_RPi1.3, Con_Stepdown1.3, Con_Switch1.3, CurrentDrawOpAmp1.4 (V-), CurrentSensor1.3 (GND), CurrentSensor1.5 (I2), LevelShifter_Display1.4 (GND), LevelShifter_Display1.9 (GND), MD_L1.1 (GND), MD_L1.7 (GND), MD_R1.1 (GND), MD_R1.7 (GND), MicroController1.4 (GND), MicroController1.27 (GND), MicroController1.35 (GND), POT_Batt_12.1, POT_Batt_23.1, POT_Batt_P1.1, POT_P_Sw_Sense1.1, Q1.1 (E), R_I_4.1
I2C_SCL: Con_RPi1.1, LevelShifter_Display1.2 (LV2), MicroController1.24 (A5/SCL)
I2C_SDA: Con_RPi1.2, LevelShifter_Display1.1 (LV1), MicroController1.22 (A4/SDA)
MS1_L: MD_L1.10 (MS1), MicroController1.13 (D10/SS)
MS1_R: MD_R1.10 (MS1), MicroController1.9 (D6/AINO/OC0A)
MS2_L: MD_L1.11 (MS2), MicroController1.14 (D11/MOSI)
MS2_R: MD_R1.11 (MS2), MicroController1.8 (D5/T1/OC0B)
MS3_L: MD_L1.12 (MS3), MicroController1.15 (D12/MISO)
MS3_R: MD_R1.12 (MS3), MicroController1.7 (D4/XCK/T0)
unnamed: C_P_Sw_Hold1.1, Diode_P_In1.1 (K), POT_P_Sw_Sense1.3, R_BaseLim1.2, R_C_Lim1.2
unnamed: Con_Display1.1, LevelShifter_Display1.11 (HV2)
unnamed: Con_Display1.2, LevelShifter_Display1.12 (HV1)
unnamed: Con_Motor_L1.1, MD_L1.3 (1B)
unnamed: Con_Motor_L1.2, MD_L1.4 (1A)
unnamed: Con_Motor_L1.3, MD_L1.5 (2A)
unnamed: Con_Motor_L1.4, MD_L1.6 (2B)
unnamed: Con_Motor_R1.1, MD_R1.3 (1B)
unnamed: Con_Motor_R1.2, MD_R1.4 (1A)
unnamed: Con_Motor_R1.3, MD_R1.5 (2A)
unnamed: Con_Motor_R1.4, MD_R1.6 (2B)
unnamed: Con_P_Sw1.2, R_C_Lim1.1
unnamed: CurrentDrawOpAmp1.2 (-), R_I_1.1, R_I_3.1
unnamed: CurrentDrawOpAmp1.3 (+), R_I_2.2, R_I_4.2
unnamed: CurrentSensor1.2 (OUT), R_I_1.2
unnamed: MD_L1.13 (~RESET), MD_L1.14 (~SLEEP)
unnamed: MD_R1.13 (~RESET), MD_R1.14 (~SLEEP)
unnamed: POT_Batt_12.3, Q5.3 (D)
unnamed: POT_Batt_23.3, Q4.3 (D)
unnamed: POT_Batt_P1.3, Q2.3 (D)
unnamed: POT_PowerGate1.3, Q1.3 (C)
unnamed: Q1.2 (B), R_BaseLim1.1
P_IN: Diode_P_In1.2 (A), MicroController1.17 (D13/SCK)
P_Sw_Sense: MicroController1.18 (A7), POT_P_Sw_Sense1.2
PowerGate: POT_PowerGate1.2, Q2.2 (G), Q3.1 (G), Q4.2 (G), Q5.2 (G)
RPI1: Con_AddOn1.3, Con_RPi1.6
RPI2: Con_AddOn1.2, Con_RPi1.7
RPI3: Con_AddOn1.1, Con_RPi1.8
Step_L: MD_L1.15 (STEP), MicroController1.12 (D9/OC1A)
Step_R: MD_R1.15 (STEP), MicroController1.6 (D3/OC2B)
Sw1: Con_Switch1.2, MicroController1.2 (D0/RXD)
Sw2: Con_Switch1.1, MicroController1.5 (D2)

Notes on the sheet:
High side switch of supply voltage: +BATT is coming from battery, +12V is what is being switched on/off that the rest of the ciruit connects to.
Adjust POT_PowerGate1 so that PowerGate drops to < 1V when switched on, otherwise Q5 does not open.
*BEFORE* plugging in the uC, adjust POT_Batt_x so that all ADC voltages are always < 3.3V. I recommend hitting 3.3V for 4.5V * [1, 2, 3] respectively. Keep in mind that Q5 might not fully open due to high PowerGate voltages.
*BEFORE* plugging in the uC, adjust POT_P_Sw_Sense1 so that P_Sw_Sense is slightly below 3.3V for +BATT = 12.6V and the power button (Con_P_Sw1) pressed.

Board: 2 copper layers, 82.5 x 63.5 mm, 36 parts (0 on the bottom side), 55 nets.

## KiCad design power/power.kicad_pcb

Parts:
Battery_Connector1: Conn_01x06; JST_XH_B6B-XH-A_1x06_P2.50mm_Vertical
C1, C2: 1uF; CP_Radial_D5.0mm_P2.50mm
CellVoltageOpAmp1: LM358
Con_PowerBoard2MainBoard1: Conn_01x09_Male; PinHeader_1x11_P2.54mm_Vertical
Con_Stepdown_Board1: Conn_01x03; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
CurrentDrawOpAmp1: LM358; DIP-8_W7.62mm_Socket
CurrentSensor1: ACS712Breakout; ACS712BreakoutBoardUpSideDown
Diode1: D; D_T-1_P5.08mm_Horizontal
Q1: TIP120; TO-220-3_Vertical
RV1: R_POT_TRIM; Potentiometer_Bourns_3296W_Vertical
R_Cell1_Vdiv_A1: 33K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R_Cell1_Vdiv_B1: 100K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R_I_1: 10K; R_Axial_DIN0207_L6.3mm_D2.5mm_P5.08mm_Vertical
R_I_2: 33K; R_Axial_DIN0207_L6.3mm_D2.5mm_P5.08mm_Vertical
R_I_3: 33K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R_I_4: 22K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R_T1: 1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P5.08mm_Vertical
R_V_Cell2_1, R_V_Cell2_2, R_V_Cell3_2: 47K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R_V_Cell2_3, R_V_Cell2_4, R_V_Cell3_3, R_V_Cell3_4: 33K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R_V_Cell3_1: 47K; R_Axial_DIN0207_L6.3mm_D2.5mm_P5.08mm_Vertical
Switch_Connector1: Conn_01x04; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical

Connections:
+5V: C1.1, C2.1, CellVoltageOpAmp1.8 (V+), Con_PowerBoard2MainBoard1.7, Con_Stepdown_Board1.2, CurrentDrawOpAmp1.8 (V+), CurrentSensor1.1, R_I_2.2
+BATT: Battery_Connector1.3, Battery_Connector1.4, Con_PowerBoard2MainBoard1.8, Con_PowerBoard2MainBoard1.9, Con_Stepdown_Board1.1, R_V_Cell3_2.1, Switch_Connector1.1
BATT_Cell_1_2: Battery_Connector1.2, R_Cell1_Vdiv_A1.1, R_V_Cell2_1.2
BATT_Cell_2_3: Battery_Connector1.1, R_V_Cell2_2.1, R_V_Cell3_1.2
GND: C1.2, C2.2, CellVoltageOpAmp1.4 (V-), Con_PowerBoard2MainBoard1.10, Con_PowerBoard2MainBoard1.11, Con_Stepdown_Board1.3, CurrentDrawOpAmp1.4 (V-), CurrentSensor1.3, Q1.2 (C), R_Cell1_Vdiv_B1.2, R_I_4.2, R_V_Cell2_4.1, R_V_Cell3_4.1
unnamed: Battery_Connector1.5, Battery_Connector1.6, CurrentSensor1.4
unnamed: CellVoltageOpAmp1.1, Con_PowerBoard2MainBoard1.5, R_V_Cell2_3.2
unnamed: CellVoltageOpAmp1.2 (-), R_V_Cell2_1.1, R_V_Cell2_3.1
unnamed: CellVoltageOpAmp1.3 (+), R_V_Cell2_2.2, R_V_Cell2_4.2
unnamed: CellVoltageOpAmp1.5 (+), R_V_Cell3_2.2, R_V_Cell3_4.2
unnamed: CellVoltageOpAmp1.6 (-), R_V_Cell3_1.1, R_V_Cell3_3.1
unnamed: CellVoltageOpAmp1.7, Con_PowerBoard2MainBoard1.4, R_V_Cell3_3.2
unnamed: Con_PowerBoard2MainBoard1.3, R_Cell1_Vdiv_A1.2, R_Cell1_Vdiv_B1.1
unnamed: Con_PowerBoard2MainBoard1.6, CurrentDrawOpAmp1.1, R_I_3.1
unnamed: CurrentDrawOpAmp1.2 (-), R_I_1.2, R_I_3.2
unnamed: CurrentDrawOpAmp1.3 (+), R_I_2.1, R_I_4.1
unnamed: CurrentSensor1.2, R_I_1.1
unnamed: CurrentSensor1.5, Q1.3 (E), RV1.1
unnamed: Diode1.1 (K), RV1.3, R_T1.1, Switch_Connector1.2
unnamed: Q1.1 (B), R_T1.2
P_Check: Con_PowerBoard2MainBoard1.1, RV1.2
P_IN: Con_PowerBoard2MainBoard1.2, Diode1.2 (A)

Notes on the sheet:
Power Board

Board: 2 copper layers, 27 parts (0 on the bottom side), 22 nets.

## KiCad design AppCVRobot.kicad_pcb

Board: 2 copper layers, 38 parts (0 on the bottom side), 54 nets.

Parts:
Battery_Connector1: Conn_01x06; JST_XH_B6B-XH-A_1x06_P2.50mm_Vertical
C1, C2: 1uF; CP_Radial_D5.0mm_P2.50mm
C_MD_L1, C_MD_L2: 100uF; CP_Radial_D5.0mm_P2.50mm
CellVoltageOpAmp1: LM358; DIP-8_W7.62mm_Socket
Con_MainBoard2PowerBoard1: Conn_01x09_Female; PinSocket_1x11_P2.54mm_Vertical
Con_Motor_L1: Conn_01x04; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
Con_Motor_R1: Conn_01x04; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
Con_PowerBoard2MainBoard1: Conn_01x09_Male; PinHeader_1x11_P2.54mm_Vertical
Con_Stepdown_Board1: Conn_01x03; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
CurrentDrawOpAmp1: LM358; DIP-8_W7.62mm_Socket
CurrentSensor1: ACS712Breakout; ACS712BreakoutBoardUpSideDown
Diode1: D; D_T-1_P5.08mm_Horizontal
Display_Connector1: Conn_01x04; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
MD_L1: Pololu_Breakout_A4988; Pololu_Breakout-16_15.2x20.3mm
MD_R1: Pololu_Breakout_A4988; Pololu_Breakout-16_15.2x20.3mm
MicroController1: IZOKEEProMini; Arduino_Pro_Mini_Socket_IZOKEE
Q1: TIP120; TO-220-3_Vertical
RPi_Connector1: Conn_01x05; JST_XH_B5B-XH-A_1x05_P2.50mm_Vertical
RV1: R_POT_TRIM; Potentiometer_Bourns_3296W_Vertical
R_Cell1_Vdiv_A1: 33K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R_Cell1_Vdiv_B1: 100K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R_I_1: 10K; R_Axial_DIN0207_L6.3mm_D2.5mm_P5.08mm_Vertical
R_I_2: 33K; R_Axial_DIN0207_L6.3mm_D2.5mm_P5.08mm_Vertical
R_I_3: 33K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R_I_4: 22K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R_T1: 1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P5.08mm_Vertical
R_V_Cell2_1, R_V_Cell2_2, R_V_Cell3_2: 47K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R_V_Cell2_3, R_V_Cell2_4, R_V_Cell3_3, R_V_Cell3_4: 33K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R_V_Cell3_1: 47K; R_Axial_DIN0207_L6.3mm_D2.5mm_P5.08mm_Vertical
Switch_Connector1: Conn_01x04; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
U1: LevelShifter; LevelShifterBreakoutBoard

Connections:
+3V3: MD_L1.2, MD_R1.2, MicroController1.25, RPi_Connector1.4, U1.3
+5V: C1.1, C2.1, CellVoltageOpAmp1.8, Con_MainBoard2PowerBoard1.7, Con_PowerBoard2MainBoard1.7, Con_Stepdown_Board1.2, CurrentDrawOpAmp1.8, CurrentSensor1.1, Display_Connector1.1, RPi_Connector1.5, R_I_2.2, U1.10
+BATT: Battery_Connector1.3, Battery_Connector1.4, C_MD_L1.1, C_MD_L2.1, Con_MainBoard2PowerBoard1.8, Con_MainBoard2PowerBoard1.9, Con_PowerBoard2MainBoard1.8, Con_PowerBoard2MainBoard1.9, Con_Stepdown_Board1.1, Diode1.1, MD_L1.8, MD_R1.8, RV1.3, R_T1.1, R_V_Cell3_2.1
BATT_Cell_1_2: Battery_Connector1.2, R_Cell1_Vdiv_A1.1, R_V_Cell2_1.2
BATT_Cell_2_3: Battery_Connector1.1, R_V_Cell2_2.1, R_V_Cell3_1.2
Dir_L: MD_L1.16, MicroController1.9
Dir_R: MD_R1.16, MicroController1.1
Enable_Steppers: MD_L1.9, MD_R1.9, MicroController1.11
GND: C1.2, C2.2, C_MD_L1.2, C_MD_L2.2, CellVoltageOpAmp1.4, Con_MainBoard2PowerBoard1.10, Con_MainBoard2PowerBoard1.11, Con_PowerBoard2MainBoard1.10, Con_PowerBoard2MainBoard1.11, CurrentDrawOpAmp1.4, CurrentSensor1.3, Display_Connector1.2, MD_L1.1, MD_L1.7, MD_R1.1, MD_R1.7, MicroController1.4, MicroController1.27, MicroController1.35, Q1.2, RPi_Connector1.3, R_Cell1_Vdiv_B1.2, R_I_4.2, R_V_Cell2_4.1, R_V_Cell3_4.1, Switch_Connector1.1, Switch_Connector1.2, U1.4, U1.9
I2C_SCL: MicroController1.24, RPi_Connector1.2, U1.2
I2C_SDA: MicroController1.22, RPi_Connector1.1, U1.1
MS1_L: MD_L1.10, MicroController1.13
MS1_R: MD_R1.10, MicroController1.8
MS2_L: MD_L1.11, MicroController1.14
MS2_R: MD_R1.11, MicroController1.7
MS3_L: MD_L1.12, MicroController1.15
MS3_R: MD_R1.12, MicroController1.6
unnamed: Battery_Connector1.5, Battery_Connector1.6, CurrentSensor1.4
unnamed: CellVoltageOpAmp1.1, Con_PowerBoard2MainBoard1.5, R_V_Cell2_3.2
unnamed: CellVoltageOpAmp1.2, R_V_Cell2_1.1, R_V_Cell2_3.1
unnamed: CellVoltageOpAmp1.3, R_V_Cell2_2.2, R_V_Cell2_4.2
unnamed: CellVoltageOpAmp1.5, R_V_Cell3_2.2, R_V_Cell3_4.2
unnamed: CellVoltageOpAmp1.6, R_V_Cell3_1.1, R_V_Cell3_3.1
unnamed: CellVoltageOpAmp1.7, Con_PowerBoard2MainBoard1.4, R_V_Cell3_3.2
unnamed: Con_MainBoard2PowerBoard1.3, MicroController1.23
unnamed: Con_MainBoard2PowerBoard1.4, MicroController1.21
unnamed: Con_MainBoard2PowerBoard1.5, MicroController1.20
unnamed: Con_MainBoard2PowerBoard1.6, MicroController1.19
unnamed: Con_Motor_L1.1, MD_L1.3
unnamed: Con_Motor_L1.2, MD_L1.4
unnamed: Con_Motor_L1.3, MD_L1.5
unnamed: Con_Motor_L1.4, MD_L1.6
unnamed: Con_Motor_R1.1, MD_R1.3
unnamed: Con_Motor_R1.2, MD_R1.4
unnamed: Con_Motor_R1.3, MD_R1.5
unnamed: Con_Motor_R1.4, MD_R1.6
unnamed: Con_PowerBoard2MainBoard1.3, R_Cell1_Vdiv_A1.2, R_Cell1_Vdiv_B1.1
unnamed: Con_PowerBoard2MainBoard1.6, CurrentDrawOpAmp1.1, R_I_3.1
unnamed: Con_Stepdown_Board1.3, Q1.3, RV1.1
unnamed: CurrentDrawOpAmp1.2, R_I_1.2, R_I_3.2
unnamed: CurrentDrawOpAmp1.3, R_I_2.1, R_I_4.1
unnamed: CurrentSensor1.2, R_I_1.1
unnamed: CurrentSensor1.5, Switch_Connector1.3, Switch_Connector1.4
unnamed: Display_Connector1.3, U1.11
unnamed: Display_Connector1.4, U1.12
unnamed: MD_L1.13, MD_L1.14
unnamed: MD_R1.13, MD_R1.14
unnamed: Q1.1, R_T1.2
PCheck: Con_MainBoard2PowerBoard1.1, MicroController1.18
P_Check: Con_PowerBoard2MainBoard1.1, RV1.2
P_IN: Con_PowerBoard2MainBoard1.2, Diode1.2
PowerIN: Con_MainBoard2PowerBoard1.2, MicroController1.17
Step_L: MD_L1.15, MicroController1.10
Step_R: MD_R1.15, MicroController1.2

## Commit log

2019-09-22 Mainboard
2019-09-24 Board split into main and power. Proper voltage difference forming to get cell voltages. current measurement.
2019-09-26 Added levelshifter for LCD display
2019-09-29 Various fixes/mods while building
2019-10-02 Added power switch connector
2020-01-22 Added two files hoping that they make the "missing parts" problem go away
2020-02-25 main changes
2020-02-27 first prototype
2020-02-27 probably unneeded file
2020-02-27 again
2020-02-27 pwm pins
2020-02-27 larger capacitor footprints
2020-03-04 Mainboard changes
2020-03-05 Cleanup directory/files
2020-03-05 Major re-layouting and cleanup
2020-03-05 Minor polishing for submission
2020-03-06 mirrored CV&RS label, moved board outline to correct layer
2020-03-17 Various smaller fixes
2020-03-17 Updated component values in layout
2020-04-09 some project settings
2020-04-16 New power circuitry and layout
2020-05-30 - 200k potis for cell voltage sensing - hints on setting up the trim potis - Better layout of labels on PCB
